# Keil uVision project STM32_Kit.uvprojx, settings and files
target LT_STM32_Kit (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\LT_BSP\LT_LED;..\LT_BSP\LT_KEY;..\LT_BSP\LT_BEEP;..\LT_BSP\LT_RELAY;..\LT_BSP\LT_IR_SW;..\LT_BSP\LT_IR_MAN;..\LT_BSP\LT_DHT11;..\LT_BSP\LT_ADC;..\LT_BSP\LT_PWM;..\LT_BSP\LT_DS18B20;..\LT_BSP\LT_OLED;..\LT_BSP\LT_MATRIX_KEY;..\LT_BSP\LT_RC522;..\LT_BSP\LT_MAX30102;..\LT_BSP\LT_DS1302;..\LT_BSP\LT_TIMER;..\LT_BSP\LT_VOICE;..\LT_BSP\LT_ULN2003;..\LT_BSP\FDC2214;..\LT_BSP\LT_MPU6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group LT_BSP
    ../LT_BSP/LT_KEY/: lt_key.c
    ../LT_BSP/LT_LED/: lt_led.c
    ../LT_BSP/LT_BEEP/: lt_beep.c
    ../LT_BSP/LT_RELAY/: lt_relay.c
    ../LT_BSP/LT_IR_SW/: lt_ir_switch.c
    ../LT_BSP/LT_IR_MAN/: lt_ir_man.c
    ../LT_BSP/LT_DHT11/: lt_dht11.c
    ../LT_BSP/LT_ADC/: lt_adc.c
    ../LT_BSP/LT_PWM/: lt_pwm.c
    ../LT_BSP/LT_DS18B20/: lt_ds18b20.c
    ../LT_BSP/LT_OLED/: lt_oled.c
    ../LT_BSP/LT_MATRIX_KEY/: lt_matrix_key.c
    ../LT_BSP/LT_RC522/: lt_RC522.c
    ../LT_BSP/LT_DS1302/: lt_ds1302.c
    ../LT_BSP/LT_TIMER/: lt_timer.c
    ../LT_BSP/LT_VOICE/: lt_voice.c
    ../LT_BSP/LT_ULN2003/: lt_uln2003.c
    ../LT_BSP/FDC2214/: fdc2214_iic.c lt_fdc2214.c
    ../LT_BSP/LT_MPU6050/: It_mpu6050.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_spi.c
  group README
    ../: README.TXT
